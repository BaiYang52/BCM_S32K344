# IAR project BCM_APP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K344 NXP S32K344
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: ARMCM7_DP; BRS_COMP_IAR; BRS_PLATFORM_AMR; DISABLE_MCAL_INTERMODULE_ASR_CHECK; BRS_ENABLE_CAN_SUPPORT
  ICCARM.CCIncludePath2: _SourceCode\Base; Davinci_Project\Appl\; Davinci_Project\Appl\GenData\; Davinci_Project\Appl\GenData\Components; Davinci_Project\Appl\GenData\include; Davinci_Project\Appl\Source; CBD2300384_D00\ThirdParty\Mcal_S32k\Supply\SW32K3_RTD_4.4_2.0.1\eclipse\plugins\Mcu_TS_T40D34M20I1R0\include; CBD2300384_D00\ThirdParty\Mcal_S32k\Supply\SW32K3_RTD_4.4_2.0.1\eclipse\plugins\Base_TS_T40D34M20I1R0\header; CBD2300384_D00\ThirdParty\Mcal_S32k\Supply\SW32K3_RTD_4.4_2.0.1\eclipse\plugins\Base_TS_T40D34M20I1R0\include; CBD2300384_D00\ThirdParty\Mcal_S32k\Supply\SW32K3_RTD_4.4_2.0.1\eclipse\plugins\Base_TS_T40D34M20I1R0\wizard_data\S32K344; CBD2300384_D00\ThirdParty\Mcal_S32k\Supply\SW32K3_RTD_4.4_2.0.1\eclipse\plugins\Port_TS_T40D34M20I1R0\include; CBD2300384_D00\ThirdParty\Mcal_S32k\Supply\SW32K3_RTD_4.4_2.0.1\eclipse\plugins\Dio_TS_T40D34M20I1R0\include; CBD2300384_D00\Components\_Common\Implementation; CBD2300384_D00\Components\Os\Implementation; CBD2300384_D00\Components\VStdLib\Implementation; CBD2300384_D00\Components\BswM\Implementation; CBD2300384_D00\Components\Det\Implementation; CBD2300384_D00\Components\EcuM\Implementation; CBD2300384_D00\Components\Mcal_S32k\Implementation
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: BCM_APP.srec
  ILINK.IlinkOutputFile: BCM_APP.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; ARMCM7_DP; START_FROM_FLASH
  ICCARM.CCOptLevel: 3
  group Appl/GenData
    Davinci_Project/Appl/GenData/: BswM_Lcfg.c Det_Cfg.c EcuM_Cfg.c EcuM_Init_Cfg.c EcuM_Init_PBcfg.c EcuM_PBcfg.c Os_AccessCheck_Lcfg.c Os_Alarm_Lcfg.c Os_Application_Lcfg.c Os_Barrier_Lcfg.c Os_Core_Lcfg.c Os_Counter_Lcfg.c Os_Error_Lcfg.c Os_Hal_Context_Lcfg.c Os_Hal_Core_Lcfg.c Os_Hal_Entry_Lcfg.c Os_Hal_EntryAsm_Lcfg.asm Os_Hal_Interrupt_Lcfg.c Os_Hal_Kernel_Lcfg.c Os_Hal_MemoryProtection_Lcfg.c Os_Hal_Timer_Lcfg.c Os_Hook_Lcfg.c Os_Ioc_Lcfg.c Os_Isr_Lcfg.c Os_MemoryProtection_Lcfg.c Os_Peripheral_Lcfg.c Os_Resource_Lcfg.c Os_Scheduler_Lcfg.c Os_ScheduleTable_Lcfg.c Os_ServiceFunction_Lcfg.c Os_Spinlock_Lcfg.c Os_Stack_Lcfg.c Os_Task_Lcfg.c Os_TimingProtection_Lcfg.c Os_Trace_Lcfg.c Os_XSignal_Lcfg.c Rte.c vBrs_Lcfg.c vLinkGen_Lcfg.c
  group Appl/GenData/src
    Davinci_Project/Appl/GenData/src/: Clock_Ip_Cfg.c Clock_Ip_PBcfg.c Mcu_Cfg.c Mcu_PBcfg.c OsIf_Cfg.c Power_Ip_Cfg.c Power_Ip_PBcfg.c Ram_Ip_Cfg.c Ram_Ip_PBcfg.c
  group Appl/Source
    Davinci_Project/Appl/Source/: BswM_Callout_Stubs.c EcuM_Callout_Stubs.c Os_Callout_Stubs.c
  group BSW/BswM
    CBD2300384_D00/Components/BswM/Implementation/: BswM.c
  group BSW/Det
    CBD2300384_D00/Components/Det/Implementation/: Det.c
  group BSW/EcuM
    CBD2300384_D00/Components/EcuM/Implementation/: EcuM.c
  group BSW/Os
    CBD2300384_D00/Components/Os/Implementation/: Os_AccessCheck.c Os_Alarm.c Os_Application.c Os_ArrayList.c Os_Barrier.c Os_Bit.c Os_BitArray.c Os_Core.c Os_Counter.c Os_Deque.c Os_Error.c Os_Event.c Os_Fifo.c Os_Fifo08.c Os_Fifo16.c Os_Fifo32.c Os_FifoRef.c Os_Hal_Compiler_Arm.c Os_Hal_Compiler_Iar.c Os_Hal_Compiler_TiInt.asm Os_Hal_Context.c Os_Hal_ContextAsm.asm Os_Hal_Core.c Os_Hal_Entry.c Os_Hook.c Os_Interrupt.c Os_Ioc.c Os_Isr.c Os_Job.c Os_Lock.c Os_MemoryProtection.c Os_Peripheral.c Os_PriorityQueue.c Os_Resource.c Os_Scheduler.c Os_ScheduleTable.c Os_ServiceFunction.c Os_Spinlock.c Os_Stack.c Os_Task.c Os_Thread.c Os_Timer.c Os_TimingProtection.c Os_Trace.c Os_Trap.c Os_XSignal.c
  group BSW/VStdlib
    CBD2300384_D00/Components/VStdLib/Implementation/: vstdlib.c
  group Device
    _SourceCode/StartUp/: ARMBrsHw_CortexM.c ARMBrsHwIntTb_CortexM.c ARMStartup_CortexM.c BrsHw.c BrsMain.c BrsMain_Appl.c BrsMain_Callout_Stubs.c BrsMainStartup.c exceptions.c startup_cm7.asm Vector_Table.asm
